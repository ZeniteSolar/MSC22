# Repository ZeniteSolar/MSC22

File README.md:

# MSC22
Atalização do Módulo Sensor Can 19 https://github.com/ZeniteSolar/MSC19  Agora com alimentação bipolar +/- 15V para os sensores. Estágio analógico devidamente ajustado.

## KiCad design hardware/currentsensormodule.kicad_pcb

Parts:
C101: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D108, D109: LL4148; D_MiniMELF
F101: Fuse; Fuse_1812_4532Metric_Pad1.30x3.40mm_HandSolder
H101: Mount_TL; MountingHole_3.2mm_M3
H102: Mount_TR; MountingHole_3.2mm_M3
H103: Mount_BL; MountingHole_3.2mm_M3
H104: Mount_BR; MountingHole_3.2mm_M3
J101: USART; PinHeader_1x04_P2.54mm_Vertical_SMD_Pin1Left
J102: STLink; PinHeader_1x05_P2.54mm_Vertical_SMD_Pin1Left
J103: Sensor1; PhoenixContact_MSTBA_2,5_4-G-5,08_1x04_P5.08mm_Horizontal
J104: Sensor2; PhoenixContact_MSTBA_2,5_4-G-5,08_1x04_P5.08mm_Horizontal
LOGO101: Logo_Open_Hardware_Small; OSHW-Logo2_7.3x6mm_SilkScreen
SYM101, SYM102, SYM103, SYM104, SYM105: (no value)

Connections:
+3V3: D109.1 (K); also elsewhere on the board
+15V: J103.2, J104.2; also elsewhere on the board
-15V: J103.1, J104.1; also elsewhere on the board
/Bipolar Analog/in1+: J103.3; also elsewhere on the board
/Bipolar Analog/in2+: J104.3; also elsewhere on the board
/CANBUS CONN/CAN_18V: F101.1; also elsewhere on the board
/POWER SUPPLY/+18V: D108.1 (K); also elsewhere on the board
/STM32/RESET: J101.1; also elsewhere on the board
/STM32/SWCLK: J102.4; also elsewhere on the board
/STM32/SWDIO: J102.2; also elsewhere on the board
/STM32/SWO: J102.3; also elsewhere on the board
/STM32/USART1_RX: J101.2; also elsewhere on the board
/STM32/USART1_TX: J101.3; also elsewhere on the board
GND: C101.1, J101.4, J102.5, J103.4, J104.4; also elsewhere on the board
unnamed: C101.2, D109.2 (A), J102.1
unnamed: D108.2 (A), F101.2

Parts:
C102, C103, C104, C105, C106, C107, C108, C109: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D101, D102, D103, D104: 3V9; D_MiniMELF_Handsoldering
R101, R102: 30; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R103, R104, R105, R106, R111, R112, R113, R114, R115, R116: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R107, R108, R109, R110: 560; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R117, R118: 22k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TP101: in+1; TestPoint_Pad_2.0x2.0mm
TP102: in+2; TestPoint_Pad_2.0x2.0mm
TP103: op_a_in-1; TestPoint_Pad_2.0x2.0mm
TP104: op_a_in+1; TestPoint_Pad_2.0x2.0mm
TP105: op_a_in-2; TestPoint_Pad_2.0x2.0mm
TP106: op_a_in+2; TestPoint_Pad_2.0x2.0mm
TP107: op_a_out1; TestPoint_Pad_2.0x2.0mm
TP108: op_a_out2; TestPoint_Pad_2.0x2.0mm
TP109: op_b_in+1; TestPoint_Pad_2.0x2.0mm
TP110: op_b_in+2; TestPoint_Pad_2.0x2.0mm
TP111: op_b_out1; TestPoint_Pad_2.0x2.0mm
TP112: op_b_out2; TestPoint_Pad_2.0x2.0mm
U101: LM324; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
+3V3: D101.1 (K), D103.1 (K); also elsewhere on the board
+15V: C108.1, R117.1, R118.1, U101.4 (V+); also elsewhere on the board
-15V: C109.2, U101.11 (V-); also elsewhere on the board
/Bipolar Analog/in1+: R101.1, R104.2, TP101.1; also elsewhere on the board
/Bipolar Analog/in2+: R102.1, R106.2, TP102.1; also elsewhere on the board
/Bipolar Analog/out1: C104.2, D101.2 (A), D102.1 (K), TP111.1, U101.13 (-), U101.14; also elsewhere on the board
/Bipolar Analog/out2: C105.2, D103.2 (A), D104.1 (K), TP112.1, U101.1, U101.2 (-); also elsewhere on the board
GND: C102.2, C103.2, C106.2, C107.2, C108.2, C109.1, D102.2 (A), D104.2 (A), R101.2, R102.2, R103.2, R105.2, R108.1, R110.1; also elsewhere on the board
unnamed: C102.1, R111.1, R113.2
unnamed: C103.1, R112.1, R114.2
unnamed: C104.1, R113.1, R115.2
unnamed: C105.1, R114.1, R116.2
unnamed: C106.1, R115.1, R117.2, TP109.1, U101.12 (+)
unnamed: C107.1, R116.1, R118.2, TP110.1, U101.3 (+)
unnamed: R103.1, R107.2, TP103.1, U101.9 (-)
unnamed: R104.1, R108.2, TP104.1, U101.10 (+)
unnamed: R105.1, R109.2, TP105.1, U101.6 (-)
unnamed: R106.1, R110.2, TP106.1, U101.5 (+)
unnamed: R107.1, R111.2, TP107.1, U101.8
unnamed: R109.1, R112.2, TP108.1, U101.7

Notes on the sheet:
https://www.edn.com/electronics-blogs/bakers-best/4418766/Closer-to-real-world-analog-filters

Parts:
C117, C118, C122, C123, C127, C130: 4.7u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C119, C120, C121, C124, C125, C126, C128, C129: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
U103, U104: K78L15-1000R3; TO-220-3_Horizontal_Tabless_SMD
U105: AMS1117-5; SOT-223-3_TabPin2
U106: AMS1117-3.3; SOT-223-3_TabPin2

Connections:
+3V3: C129.2, C130.2, U106.2 (VO); also elsewhere on the board
+5V: C126.2, C127.2, C128.2, U105.2 (VO), U106.3 (VI); also elsewhere on the board
+15V: C121.2, C122.2, C124.2, U103.3 (VO), U105.3 (VI); also elsewhere on the board
-15V: C123.2, C125.2, U104.2 (GND); also elsewhere on the board
/POWER SUPPLY/+18V: C117.2, C118.2, C119.2, C120.2, U103.1 (VI), U104.1 (VI); also elsewhere on the board
GND: C117.1, C118.1, C119.1, C120.1, C121.1, C122.1, C123.1, C124.1, C125.1, C126.1, C127.1, C128.1, C129.1, C130.1, U103.2 (GND), U104.3 (VO), U105.1 (GND), U106.1 (GND); also elsewhere on the board

Parts:
J105, J106: RJ45; RJ45_YH59_01

Connections:
/CANBUS CONN/CAN_18V: J105.4, J105.5, J106.4, J106.5; also elsewhere on the board
/CANBUS CONN/CAN_H: J105.1, J106.1; also elsewhere on the board
/CANBUS CONN/CAN_L: J105.2, J106.2; also elsewhere on the board
GND: J105.3, J105.6, J105.7, J105.8, J105.9 (SH), J106.3, J106.6, J106.7, J106.8, J106.9 (SH); also elsewhere on the board

Parts:
C131: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C132: 4.7n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D107: pesd1can; SOT-23
R124: 4k7; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R125: NC; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R126: 300; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R127, R128: 520; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TP501: TxCAN; TestPoint_Pad_2.0x2.0mm
TP502: RxCAN; TestPoint_Pad_2.0x2.0mm
TP503: CAN_H; TestPoint_Pad_2.0x2.0mm
TP504: CAN_L; TestPoint_Pad_2.0x2.0mm
U501: MCP2561-E-SN; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5V: C131.2, U501.3 (VDD); also elsewhere on the board
/CANBUS CONN/CAN_H: D107.1 (A1), R125.2, R127.2, TP503.1, U501.7 (CANH); also elsewhere on the board
/CANBUS CONN/CAN_L: D107.2 (A2), R125.1, R128.1, TP504.1, U501.6 (CANL); also elsewhere on the board
/CANBUS/CAN_RX: TP502.1, U501.4 (RXD); also elsewhere on the board
/CANBUS/CAN_TX: TP501.1, U501.1 (TXD); also elsewhere on the board
GND: C131.1, C132.2, D107.3 (common), R124.2, U501.2 (VSS); also elsewhere on the board
unnamed: C132.1, R126.1, R127.1, R128.2
unnamed: R124.1, U501.8 (STBY)
unnamed: R126.2, U501.5 (SPLIT)

Parts:
C110, C111, C112, C113, C114, C115, C116: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D105, D106: LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R119, R120, R121, R123, R302: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R122: BOOT0; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R301: JUMP0; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
U301: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm

Connections:
+3V3: C110.2, C111.2, C112.2, C113.2, C114.2, C115.2, R119.2, R122.1, R301.1, U301.1 (VBAT), U301.9 (VDDA), U301.24 (VDD), U301.36 (VDD), U301.48 (VDD); also elsewhere on the board
/Bipolar Analog/out1: U301.14 (PA4); also elsewhere on the board
/Bipolar Analog/out2: U301.13 (PA3); also elsewhere on the board
/CANBUS/CAN_RX: U301.45 (PB8); also elsewhere on the board
/CANBUS/CAN_TX: U301.46 (PB9); also elsewhere on the board
/STM32/BOOT0: R122.2, R123.1, U301.44 (BOOT0)
/STM32/JUMP0: R301.2, R302.1, U301.27 (PB14)
/STM32/LED0: R120.1, U301.25 (PB12)
/STM32/LED1: R121.1, U301.26 (PB13)
/STM32/RESET: C116.2, R119.1, U301.7 (NRST); also elsewhere on the board
/STM32/SWCLK: U301.37 (PA14); also elsewhere on the board
/STM32/SWDIO: U301.34 (PA13); also elsewhere on the board
/STM32/SWO: U301.39 (PB3); also elsewhere on the board
/STM32/USART1_RX: U301.31 (PA10); also elsewhere on the board
/STM32/USART1_TX: U301.30 (PA9); also elsewhere on the board
GND: C110.1, C111.1, C112.1, C113.1, C114.1, C115.1, C116.1, D105.1 (K), D106.1 (K), R123.2, R302.2, U301.8 (VSSA), U301.23 (VSS), U301.35 (VSS), U301.47 (VSS); also elsewhere on the board
unnamed: D105.2 (A), R121.2
unnamed: D106.2 (A), R120.2

Board: 2 copper layers, 92.0 x 54.5 mm, 111 parts (71 on the bottom side), 44 nets.

## Code that names these connections

File firmware/stm32cubemx/MSC22.ioc (part):

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Mcu.Name=STM32F103C(8-B)Tx
Mcu.Package=LQFP48
Mcu.UserName=STM32F103C8Tx
PA13.Mode=Trace_Asynchronous_SW
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Trace_Asynchronous_SW
PA14.Signal=SYS_JTCK-SWCLK
PA3.Signal=ADCx_IN3
PA4.Signal=ADCx_IN4
PB12.GPIOParameters=GPIO_Label
PB12.GPIO_Label=LED0
PB12.Signal=GPIO_Output
PB13.GPIOParameters=GPIO_Label
PB13.GPIO_Label=LED1
PB13.Signal=GPIO_Output
PB14.GPIOParameters=GPIO_Label
PB14.GPIO_Label=JUMP0
PB14.Signal=GPIO_Input
PB3.Mode=Trace_Asynchronous_SW
PB3.Signal=SYS_JTDO-TRACESWO
PB8.Mode=CAN_Activate
PB8.Signal=CAN_RX
PB9.Mode=CAN_Activate
PB9.Signal=CAN_TX
RCC.SYSCLKFreq_VALUE=64000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2022-03-04 Create deletar
2022-03-04 Add files via upload
    Projeto da PCB no kicad
2022-05-14 Mudança do conversor 18V -> +/- 15V
2022-05-14 Troca do atmega328p -> STM32F103C8T Já que tem CAN integrado e ADC 12 bits (ao invés de 10)
2022-05-16 Primeiro protótipo da PCB
2022-05-17 firmware: Added stm32cubemx initial project - only pins and clock are configured.
2022-05-17 hardware: STM32, PCB design in progress
2022-05-20 hardware: longer PCB design (main is wider)
2022-05-25 Melhoria na PCB
2022-05-25 PCB update: silkscreen drawn
2022-05-30 STLink 3v3 protection diode, silkscreen updates
2022-06-04 Silkscreen finished, module components '.csv'
2022-06-08 hardware: analog stage adjusted for application
2022-06-12 hardware: PCB size adjust
2022-06-16 hardware: fixed RJ45 footp sh pin, added shapes3D (including K78L15)
2022-06-21 simulate INA826
2022-06-21 Pequenas mudanças na silkscreen
2022-06-27 hardware: Design constraints adjusted according to JLC pcb limits
2022-06-29 hardware: Silkscreen ajusted, RDC errors fixed
2022-06-29 simulations
2022-06-29 hardware: silkscreen updated
2022-06-30 Silkscreen JLC update. Finished.
2023-04-04 add BOM
